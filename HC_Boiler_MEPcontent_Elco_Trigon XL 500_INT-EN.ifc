Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project nummer
Time: 2018-11-26T14:38:04
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Nov 26 14:38:04 2018 * Host: B3ROBRAWR2788 * Database: C:\Users\AVIT\AppData\Local\Temp\{C6A63FF5-5558-4D05-B19D-5B8E211F7E5C}\ifc * Database version: 5507 * Database creation date: Mon Nov 26 14:38:03 2018 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Mon Nov 26 14:38:03 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Nov 26 14:38:03 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project nummer
LongName: Project omschrijving; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Identity Data - Type Name: Floor Level; Building Story: yes; Name: V00; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcBoiler: XL 500, HC_Boiler_MEPcontent_Elco_Trigon XL 300-570_INT-EN:XL 500:1442103
In: V00
Type - Material: Color RGB 040-040-040, Color RGB 127-127-127, Color RAL 9016, Color RGB 023-097-171, Color RGB 178-000-000, Color RGB 245-197-44, Color RAL 7035
Type - Dimensions - Air Connection Diameter: 150 mm; Air Spigot Diameter: 155 mm; Condensate Connection Diameter: 32 mm; Condensate Spigot Diameter: 42 mm; Control Panel Depth: 190 mm; Control Panel Height: 198 mm; Equipment Depth: 1452 mm; Equipment Height: 1470 mm; Equipment Width: 746 mm; Flue Connection Diameter: 250 mm; Flue Spigot Diameter: 304 mm; Gas Connection Diameter: 50 mm; Gas Spigot Diameter: 60.3 mm; HTGF Connection Diameter: 65 mm; HTGF Spigot Diameter: 76.1 mm; HTGR Connection Diameter: 65 mm; HTGR Spigot Diameter: 76.1 mm; Panel Width: 510 mm
Type - Electrical - Equipment Apparent Power: 688.889 W; Equipment Power Factor: 0.9; Equipment Rated Power: 620 W; Frequency: 50 Hz; Maximum Overcurrent Protection: 16 A; Phase: 3; Voltage: 400 V
Type - General - Created By: JDGA; Issue Date: 27-01-2017; Issue Rev: A
Type - Identity Data - Article Type: XL 500; Base Family Version: 11.22; Content Supplier URL: www.MEPcontent.com; Copyright: © Stabiplan International BV; Custom: no; Description: Heating and Cooling Boiler; EMCS Version: 4.0; ETIM Article Class: EC011396; Family Version: 11.22; GLN: 8714231770244; Manufacturer: Elco; MEPcontent Class: BOILER_CONDENSATE_FLOW; Model: XL 500; OmniClass Number: 23.75.10.11.14; OmniClass Title: Hot Water Heat Generators; Revit Version: 2017; Type Comments: Size 500; Type Name: XL 500; URL: www.stabiplan.com; Watermarked By: www.stabiplan.com
Type - Materials and Finishes - Black: Color RGB 040-040-040; Blue: Color RGB 023-097-171; Light White: Color RAL 9016; Red: Color RGB 178-000-000; White: Color RAL 7035; Yellow: Color RGB 245-197-44
Type - Mechanical - Boiler Nominal Output 40 30: 505200 W; Boiler Nominal Output 80 60: 476700 W; Density Water 70: 27.6882; Equipment Fuel: Natural Gas (G20); Equipment Fuel Flow: 44.5 m3/hr; Flue Gas Temperature: 90 kg/K/s3; Seasonal Energy Efficiency: 98.3; Specific Heat Water: 45208.4; Unit Convert Area: 1 m2; Unit Convert Pressure Factor: 1041388; Water Content HTG: 0.071 m3
Type - Other - Category: Mechanical Equipment; Family Name: HC_Boiler_MEPcontent_Elco_Trigon XL 300-570_INT-EN; Weight Dry: 540; Weight Operating: 611
Type - Text - Article Description: Heating and Cooling Boiler; Manufacturer Art. No.: 3581649; Product Line: Elco
Pset_ManufacturerTypeInformation - Manufacturer: Elco
Constraints - Offset: 0 mm
Dimensions - Area: 5.59344 m2; Volume: 1.41667 m3
Identity Data - Design Option: Main Model; Mark: 4
Mechanical - Actual Heating Water Flow: 0.00580385 m3/s; Boiler DeltaT: 20 kg/K/s3; Boiler Water Pressure Drop: 34300 Pa; HTGF Temperature: 80 kg/K/s3; HTGR Temperature: 60 kg/K/s3; System Classification: Hydronic Supply,Hydronic Return,Other,Sanitary,Other Air,Power
Other - Family: HC_Boiler_MEPcontent_Elco_Trigon XL 300-570_INT-EN: XL 500; Family and Type: HC_Boiler_MEPcontent_Elco_Trigon XL 300-570_INT-EN: XL 500; Type: HC_Boiler_MEPcontent_Elco_Trigon XL 300-570_INT-EN: XL 500; Type Id: HC_Boiler_MEPcontent_Elco_Trigon XL 300-570_INT-EN: XL 500
Phasing - Commissioning Complete: no; Phase Created: 3. Nieuwbouw
