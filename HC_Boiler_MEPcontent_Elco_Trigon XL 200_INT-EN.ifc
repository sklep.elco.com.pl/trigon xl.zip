Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project nummer
Time: 2018-11-26T14:37:58
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Nov 26 14:37:58 2018 * Host: B3ROBRAWR2788 * Database: C:\Users\AVIT\AppData\Local\Temp\{3BA8D0AF-17EB-4B4D-A466-EAC285F7176B}\ifc * Database version: 5507 * Database creation date: Mon Nov 26 14:37:57 2018 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Mon Nov 26 14:37:57 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Nov 26 14:37:57 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project nummer
LongName: Project omschrijving; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Identity Data - Type Name: Floor Level; Building Story: yes; Name: V00; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcBoiler: XL 200, HC_Boiler_MEPcontent_Elco_Trigon XL 150-250_INT-EN:XL 200:1439522
In: V00
Type - Material: Color RGB 181-181-181, Color RGB 255-255-255, Color RGB 049-049-049, Color RGB 255-000-000, Color RGB 255-255-240
Type - Dimensions - Air Intake Diameter: 130 mm; Condensate Diameter: 32 mm; Flue Gas Diameter: 150 mm; Gas Diameter: 31.8 mm; Length 1: 1499 mm; Length 2: 1315 mm; Use Nominal Diameter: yes; Water Diameter: 50.8 mm; Width: 466 mm
Type - Identity Data - Article Type: XL 200; Base Family Version: 11.22; Content Supplier URL: www.MEPcontent.com; Copyright: ©Stabiplan International BV; Custom: no; Description: Heating and Cooling Boiler; EMCS Version: 4.0; ETIM Article Class: EC011396; Family Version: 11.14; GLN: 8714231770244; Manufacturer: Elco; MEPcontent Class: BOILER_CONDENSATE_FLOW; Model: XL 200; OmniClass Number: 23.75.10.11.14; OmniClass Title: Hot Water Heat Generators; Revit Version: 2017; Type Comments: Size 200; Type Name: XL 200; URL: www.stabiplan.com; Watermarked By: www.stabiplan.com
Type - Materials and Finishes - Black: Color RGB 049-049-049; Grey: Color RGB 181-181-181; Red: Color RGB 255-000-000; White: Color RGB 255-255-240
Type - Mechanical - Loads - Efficiency at 40/30°C Minimum Power: 110.0; Efﬁciency at 50/30ºC Min Load Net: 109.2; Efﬁciency at 80/60ºC Full Load Net: 98.2; Flue Gas Temperature at 80/60ºC Full Load: 75.00; Max. Permissible Flue Resistance: 200.00; Maximum/Minimum Water Pressure: 8-1; Maximum Temperature Setpoint: 90.00; Minimal Heating Capacity at 50/30°C: 47.0; Minimal Heating Capacity at 80/60°C: 42.0; Minimum Heat Input Min Load Net: 43.1; Noise Level: 70.3; Nominal Heating Capacity at 50/30°C: 199.9; Nominal Heating Capacity at 80/60°C: 190.4; Nominal Heat Input Full Load Net: 194.0; Nox Level (EN15502): 28; Water Content: 31.0; Weight: 332.00; Yearly Efficiency (NNG 40/30°C): 110.4
Type - Other - Category: Mechanical Equipment; Family Name: HC_Boiler_MEPcontent_Elco_Trigon XL 150-250_INT-EN; Mount Offset: 60 mm
Type - Text - Article Description: Heating and Cooling Boiler; Manufacturer Art. No.: 3581645; Product Line: Elco
Pset_ManufacturerTypeInformation - Manufacturer: Elco
Constraints - Offset: 0 mm
Dimensions - Area: 3.75133 m2; Volume: 0.81462 m3
Electrical - Power: 230 W
Identity Data - Design Option: Main Model; Mark: 4
Mechanical - Drain Fixture Units: 0; Flow Domestic Cold Water: 0 m3/s; Flow Domestic Hot Water: 0 m3/s; Flow Flue Gas: 0 m3/s; Flow Gas: 0 m3/s; Flow Supply Air: 0 m3/s; System Classification: Power,Domestic Hot Water,Other,Domestic Cold Water,Sanitary,Other,Supply Air
Other - Family: HC_Boiler_MEPcontent_Elco_Trigon XL 150-250_INT-EN: XL 200; Family and Type: HC_Boiler_MEPcontent_Elco_Trigon XL 150-250_INT-EN: XL 200; Type: HC_Boiler_MEPcontent_Elco_Trigon XL 150-250_INT-EN: XL 200; Type Id: HC_Boiler_MEPcontent_Elco_Trigon XL 150-250_INT-EN: XL 200
Phasing - Phase Created: 3. Nieuwbouw
